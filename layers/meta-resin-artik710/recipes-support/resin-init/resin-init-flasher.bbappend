# On Samsung Artik 710 we flash Resin IO on the emmc
INTERNAL_DEVICE_KERNEL_artik710 = "mmcblk0"
