LED_FILE_artik710 = "/sys/class/leds/led1/brightness"
