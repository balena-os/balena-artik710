# UPX not supported on aarch64
FILES_COMPRESS_artik710 = ""
